# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\HeaderFiles;.\Function;.\System;.\Hardware;.\Hardware\Lzh_LIB;.\Hardware\Bujin;.\Hardware\LED;.\Hardware\Move;.\Hardware\MPU6050;.\Hardware\OLED;.\Hardware\QR;.\Hardware\Servo;.\Hardware\Voice;.\Hardware\UpperCP;.\System\Delay;.\System\iic;.\System\Serial;.\System\Timer;.\System\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HeaderFiles
    ./HeaderFiles/: HeaderFiles.h
  group Function
    ./Function/: Function.c
  group System
    ./System/Delay/: Delay.c
    ./System/iic/: iic.c
    ./System/Serial/: Serial.c
    ./System/Timer/: Timer.c
    ./System/IWDG/: IWDG.c
  group Hardware
    ./Hardware/Bujin/: Bujin.c
    ./Hardware/LED/: LED.c
    ./Hardware/Move/: Move.c
    ./Hardware/MPU6050/: MPU6050.c
    ./Hardware/OLED/: OLED.c
    ./Hardware/QR/: QR.c
    ./Hardware/Servo/: MyServo.c Servo.c
    ./Hardware/UpperCP/: UpperCP.c
    ./Hardware/Voice/: Voice.c
